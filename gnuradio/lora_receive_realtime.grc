options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: lora_receive_realtime
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 432.9e6
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: |-
      The decimation determines the oversampling rate.
      A sample rate of 1e6 and decimation of 1 equals
      8 times oversampling, a decimation of 2 is 4 times
      oversampling, and so on. Set higher decimation
      for better performance, but worse accuracy.
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_lora_receiver_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[904.1e6]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_lora_receiver_0_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[903.7e6]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '0'
    port: '40868'
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: capture_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: capture_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: capture_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [lora_lora_receiver_0, frames, blocks_message_debug_0, print]
- [lora_lora_receiver_0, frames, blocks_message_debug_0, print_pdu]
- [lora_lora_receiver_0, frames, blocks_message_debug_0, store]
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0, frames, blocks_message_debug_0_0, print]
- [lora_lora_receiver_0_0, frames, blocks_message_debug_0_0, print_pdu]
- [lora_lora_receiver_0_0, frames, blocks_message_debug_0_0, store]
- [lora_lora_receiver_0_0_0, frames, blocks_message_debug_0_0_0, print]
- [lora_lora_receiver_0_0_0, frames, blocks_message_debug_0_0_0, print_pdu]
- [lora_lora_receiver_0_0_0, frames, blocks_message_debug_0_0_0, store]
- [osmosdr_source_0, '0', lora_lora_receiver_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', lora_lora_receiver_0, '0']
- [uhd_usrp_source_0, '0', lora_lora_receiver_0_0, '0']
- [uhd_usrp_source_0, '0', lora_lora_receiver_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
