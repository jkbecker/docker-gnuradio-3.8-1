options:
  parameters:
    category: Custom
    description: Send frame to DUT and receive its reponse frame if there is one.
    generate_options: qt_gui
    id: zig_capture
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2405000000'
  states: {state: disabled}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.95'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '0.95'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '0.95'
  states: {state: disabled}
- name: bar_packet_pad2_0
  id: bar_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '200'
    minoutbuf: '256000'
    pad_front: '0'
    pad_tail: '20000'
  states: {}
- name: bar_packet_pad_0
  id: bar_packet_pad
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '200'
    minoutbuf: '256000'
    pad_front: '0'
    pad_tail: '20000'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/zig.pcap"'
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp((-4+tx_gain*0.4)*np.log(10))
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_first*0.1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_second*0.1
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 192.168.0.175
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 192.168.0.175
    mtu: '10000'
    port: '52003'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_0
  id: blocks_socket_pdu
  parameters:
    host: 192.168.0.175
    mtu: '10000'
    port: '52004'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    type: complex
  states: {}
- name: channel
  id: parameter
  parameters:
    label: channel
    short_id: c
    type: intx
    value: '11'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: foo_packet_pad2_1_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '256000'
    pad_front: '0'
    pad_tail: '20000'
  states: {}
- name: foo_packet_pad2_1_0_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '256000'
    pad_front: move
    pad_tail: 20000-move
  states: {state: disabled}
- name: foo_packet_pad_0
  id: foo_packet_pad
  parameters:
    debug: 'True'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '0'
    pad_tail: '20000'
  states: {state: disabled}
- name: foo_packet_pad_0_0
  id: foo_packet_pad
  parameters:
    debug: 'True'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: offset*50
    pad_tail: 20000-offset*50
  states: {state: disabled}
- name: foo_packet_pad_1
  id: foo_packet_pad
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '256000'
    pad_front: '0'
    pad_tail: '20000'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: frame_len
  id: parameter
  parameters:
    label: frame_len
    short_id: l
    type: intx
    value: '6550'
  states: {state: disabled}
- name: freq
  id: parameter
  parameters:
    label: freq
    short_id: f
    type: intx
    value: 1000000 * (2400 + 5 * (channel-10))
  states: {state: disabled}
- name: gain_first
  id: parameter
  parameters:
    label: gain_first
    short_id: f
    type: eng_float
    value: '1'
  states: {}
- name: gain_second
  id: parameter
  parameters:
    label: gain_second
    short_id: s
    type: eng_float
    value: '1'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_oqpsk_phy_0_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sin, pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: we misuse d_delay_sec variable for step. dont enable delay
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: offset
  id: parameter
  parameters:
    label: offset
    short_id: o
    type: intx
    value: '10'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"TRUN"'
    size: '22024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: tag
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"TEST"'
    size: '22024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: tag
    type: complex
  states: {}
- name: tag
  id: parameter
  parameters:
    label: tag
    short_id: g
    type: str
    value: packet_len
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: 1000000 * (2400 + 5 * (channel-10))
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '1'
    len_tag_name: packet_len
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 192.168.0.175
    port: '52002'
  states: {}

connections:
- [bar_packet_pad2_0, '0', blocks_tag_gate_0, '0']
- [bar_packet_pad2_0, '0', qtgui_time_sink_x_0, '0']
- [bar_packet_pad_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_tag_debug_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_1_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', foo_packet_pad2_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', foo_packet_pad_1, '0']
- [blocks_multiply_const_vxx_2, '0', bar_packet_pad2_0, '0']
- [blocks_multiply_const_vxx_2, '0', bar_packet_pad_0, '0']
- [blocks_null_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [blocks_null_source_0, '0', ieee802_15_4_oqpsk_phy_0_0, '0']
- [blocks_socket_pdu_0, pdus, ieee802_15_4_oqpsk_phy_0, txin]
- [blocks_socket_pdu_0_0, pdus, bar_packet_pad2_0, in]
- [blocks_socket_pdu_0_0, pdus, bar_packet_pad_0, in]
- [blocks_socket_pdu_0_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_socket_pdu_0_0_0, pdus, ieee802_15_4_oqpsk_phy_0_0, txin]
- [blocks_tag_gate_0, '0', blocks_add_xx_0, '1']
- [foo_packet_pad2_1_0, '0', blocks_add_xx_0, '0']
- [foo_packet_pad2_1_0, '0', qtgui_time_sink_x_0_1, '0']
- [foo_packet_pad2_1_0_0, '0', blocks_add_xx_0, '1']
- [foo_packet_pad2_1_0_0, '0', qtgui_time_sink_x_0, '0']
- [foo_packet_pad_0, '0', blocks_add_xx_0, '0']
- [foo_packet_pad_0_0, '0', blocks_add_xx_0, '1']
- [foo_packet_pad_1, '0', blocks_add_xx_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_multiply_const_vxx_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_multiply_const_vxx_1, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad2_1_0_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [ieee802_15_4_oqpsk_phy_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [ieee802_15_4_oqpsk_phy_0_0, '0', foo_packet_pad2_1_0_0, '0']
- [ieee802_15_4_oqpsk_phy_0_0, '0', foo_packet_pad_0_0, '0']
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1
