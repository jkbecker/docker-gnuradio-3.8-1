options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: zig_len_dos_pluto
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2425000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 2.425e9
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '2425000000'
  states: {}
- name: mctest
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {state: disabled}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.95'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '0.95'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '95'
    value: '95'
  states: {state: disabled}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '0.95'
  states: {}
- name: bar_packet_pad2_0
  id: bar_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '256000'
    pad_front: '0'
    pad_tail: '20000'
  states: {}
- name: bar_packet_pad_0
  id: bar_packet_pad
  parameters:
    debug: 'True'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '0'
    pad_tail: '20000'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: offset
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/zig.pcap"'
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mctest
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52003'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_1_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52004'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: ''
    name: test pckt
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    name: trun pckt
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    single_key: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_1_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    single_key: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_1_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_1_1_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"tx_time"'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '128'
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tuntap_pdu_0
  id: blocks_tuntap_pdu
  parameters:
    ifn: tap0
    istunflag: 'False'
    mtu: '10000'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0, sin(pi/4), 1, sin(3*pi/4)]'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '16'
    in_type: byte
    out_type: complex
    symbol_table: '[(1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j)]'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '0'
    pad_tail: '8'
  states: {}
- name: foo_packet_pad2_1
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '256000'
    pad_front: '0'
    pad_tail: '20000'
  states: {}
- name: foo_packet_pad2_1_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '256000'
    pad_front: '2000'
    pad_tail: '0'
  states: {state: disabled}
- name: foo_packet_pad2_2
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '128000'
    pad_front: '15000'
    pad_tail: '5000'
  states: {state: disabled}
- name: foo_packet_pad_0
  id: foo_packet_pad
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: offset
    pad_tail: 10000-offset
  states: {state: disabled}
- name: foo_packet_pad_0_0
  id: foo_packet_pad
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '0'
    pad_tail: '20000'
  states: {state: disabled}
- name: foo_packet_pad_0_0_0
  id: foo_packet_pad
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '40000'
    pad_tail: 40000-40000
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: ie802_15_4_access_code_prefixer_0
  id: ie802_15_4_access_code_prefixer
  parameters:
    pad: length
    preamble: '0x000000a7'
  states: {}
- name: ieee802_15_4_access_code_prefixer_0
  id: ieee802_15_4_access_code_prefixer
  parameters:
    pad: '0x00'
    preamble: '0x000000a7'
  states: {state: disabled}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: int(samp_rate*5)
    buffer_size: '0x40000'
    cyclic: 'False'
    frequency: freq
    samplerate: int(samp_rate)
    uri: iio_uri
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(samp_rate*5)
    bbdc: 'True'
    buffer_size: '0x40000'
    frequency: freq
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    uri: iio_uri
  states: {state: disabled}
- name: iio_uri
  id: parameter
  parameters:
    label: iio_uri
    type: str
    value: usb:1.9.5
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import sin, pi
  states: {}
- name: length
  id: parameter
  parameters:
    label: length
    short_id: l
    type: intx
    value: '0x7f'
  states: {}
- name: mctest
  id: parameter
  parameters:
    label: mctest
    short_id: g
    type: eng_float
    value: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: lower nipple is sent first
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: maps chunks of 4 bis directly to qpsk symbols
  states: {}
- name: note_2
  id: note
  parameters:
    note: half sine pulse shape
  states: {}
- name: note_3
  id: note
  parameters:
    note: 4 samples per (chip) symbol
  states: {}
- name: note_4
  id: note
  parameters:
    note: delay quadrature component to get O-QPSK
  states: {}
- name: note_5
  id: note
  parameters:
    note: RRC filter missing
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Offset
    short_id: o
    type: intx
    value: '2000'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"TRUN"'
    size: '20024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"SUM"'
    size: '20024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"TEST"'
    size: '20024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_len
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [bar_packet_pad2_0, '0', blocks_multiply_const_vxx_1, '0']
- [bar_packet_pad2_0, '0', blocks_tag_gate_1, '0']
- [bar_packet_pad_0, '0', blocks_multiply_const_vxx_1, '0']
- [bar_packet_pad_0, '0', blocks_tag_debug_1, '0']
- [bar_packet_pad_0, '0', blocks_tag_gate_1, '0']
- [blocks_add_xx_0, '0', foo_packet_pad2_1_0, '0']
- [blocks_add_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_tag_gate_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_float_to_complex_0, '0', blocks_tag_debug_1_0, '0']
- [blocks_float_to_complex_0, '0', foo_packet_pad2_1, '0']
- [blocks_float_to_complex_0, '0', foo_packet_pad_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_tag_gate_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_tag_gate_1_1, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_socket_pdu_0, pdus, ie802_15_4_access_code_prefixer_0, in]
- [blocks_socket_pdu_0, pdus, ieee802_15_4_access_code_prefixer_0, in]
- [blocks_socket_pdu_0, pdus, ieee802_15_4_oqpsk_phy_0, txin]
- [blocks_socket_pdu_1, pdus, bar_packet_pad2_0, in]
- [blocks_socket_pdu_1, pdus, bar_packet_pad_0, in]
- [blocks_socket_pdu_1_0, pdus, ie802_15_4_access_code_prefixer_0, len]
- [blocks_tag_gate_0, '0', blocks_float_to_complex_0, '1']
- [blocks_tag_gate_1, '0', blocks_add_xx_0, '0']
- [blocks_tag_gate_1, '0', blocks_null_sink_0, '0']
- [blocks_tag_gate_1_0, '0', blocks_add_xx_0, '1']
- [blocks_tag_gate_1_1, '0', blocks_add_xx_0, '0']
- [blocks_tag_gate_1_1, '0', blocks_tag_gate_1_1_0, '0']
- [blocks_tag_gate_1_1_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', foo_packet_pad2_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [foo_packet_pad2_0, '0', blocks_complex_to_float_0, '0']
- [foo_packet_pad2_1, '0', blocks_multiply_const_vxx_0, '0']
- [foo_packet_pad2_1_0, '0', uhd_usrp_sink_0, '0']
- [foo_packet_pad2_2, '0', blocks_multiply_const_vxx_1, '0']
- [foo_packet_pad2_2, '0', blocks_tag_debug_1, '0']
- [foo_packet_pad2_2, '0', blocks_tag_gate_1, '0']
- [foo_packet_pad_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [foo_packet_pad_0_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ie802_15_4_access_code_prefixer_0, out, blocks_message_debug_0, print_pdu]
- [ie802_15_4_access_code_prefixer_0, out, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [ieee802_15_4_oqpsk_phy_0, '0', bar_packet_pad2_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', bar_packet_pad_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad2_2, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad_0_0_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, blocks_socket_pdu_0_0_0, pdus]
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [iio_pluto_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1
