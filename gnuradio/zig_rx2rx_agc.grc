options:
  parameters:
    category: Custom
    description: Send frame to DUT and receive its reponse frame if there is one.
    generate_options: no_gui
    id: zig_rx2rx_agc
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2405000000'
  states: {state: disabled}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.95'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '0.95'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '0.95'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/zig.pcap"'
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: foo_packet_pad2_1_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '256000'
    pad_front: '1000'
    pad_tail: '1000'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: freq
    short_id: f
    type: intx
    value: '2405000000'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sin, pi
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: tx_gain
    short_id: t
    type: intx
    value: '95'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_addr: ''
    dev_args: '""'
    iq_imbal_enb0: 'True'
    norm_gain0: 'True'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_socket_pdu_0, pdus, ieee802_15_4_oqpsk_phy_0, txin]
- [foo_packet_pad2_1_0, '0', uhd_usrp_sink_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad2_1_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1
